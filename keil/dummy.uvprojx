# Keil uVision project dummy.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dummy +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB, USE_FULL_ASSERT, USE_STDPERIPH_DRIVER, STM32F10X_MD, HSE_VALUE=12000000, HAVE_CONFIG_H
  c misc: --c99 --feedback=unused
  c include: .\src\cmsis;.\src;.\src\mcu_support_package\inc;.\src\spl\inc;.\src\spl;.\src\main\STM32F10x_Speex_Lib\include;.\src\main\STM32F10x_Speex_Lib\libspeex;.\src\main\STM32F10x_Speex_Lib\STM32;.\src\main\STM32F10x_Speex_Lib\STM32\libspeex;.\src\main\STM32F10x_Speex_Lib\STM32\include;.\src\main\STM32F10x_Speex_Lib\STM32\libspeex\arm
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\stack_protection.sct
  link misc: --feedback=unused
  group main
    ./src/main/: main.c ws2812b.c Delay.c Lcd.c ws2812b_modes.c spi.c Spx.c uart.c
  group mcu_support_package
    ./src/mcu_support_package/: system_stm32f10x.c
    ./src/mcu_support_package/arm/: startup_stm32f103xb.s
  group spl
    ./src/spl/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_usart.c
  group libspeex
    ./src/main/STM32F10x_Speex_Lib/libspeex/: bits.c buffer.c exc_10_32_table.c gain_table.c gain_table_lbr.c high_lsp_tables.c lpc.c lsp.c lsp_tables_nb.c speex.c speex_callbacks.c speex_header.c window.c os_support.c
    ./src/main/STM32F10x_Speex_Lib/STM32/libspeex/: cb_search.c filters.c ltp.c modes.c nb_celp.c quant_lsp.c vq.c
